# Keil uVision project Project.uvprojx, settings and files
target PY32F002Bx5_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F002Bx5,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\..\Drivers\PY32F002B_HAL_Driver\Inc;..\..\..\MyBSP;..\..\..\Drivers\BSP\PY32F002Bxx_Start_Kit
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ../Src/: system_py32f002b.c
    ./: startup_py32f002bxx.s
  group Application/User
    ../Src/: main.c py32f002b_it.c
  group Drivers/PY32F002B_HAL_Driver
    ../../../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_ll_utils.c py32f002b_ll_gpio.c py32f002b_ll_tim.c py32f002b_ll_adc.c py32f002b_ll_exti.c
  group MyBSP
    ../../../Drivers/BSP/PY32F002Bxx_Start_Kit/: py32f002bxx_ll_Start_Kit.c
    ../../../MyBSP/: led.c scheduler.c systick.c Delay.c tm1637.c
  group Doc
    ../: readme.txt
